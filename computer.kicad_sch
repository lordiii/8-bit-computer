File: computer.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Update High Level
Other:
- sheet RAM Select renamed MMU
- note removed: "Control Logic"
